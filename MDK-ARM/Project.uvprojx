# Keil uVision project Project.uvprojx, settings and files
target STM32746G-DISCOVERY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G-DISCOVERY
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ..\Inc;F:\STM32\Cube7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;F:\STM32\Cube7\Drivers\STM32F7xx_HAL_Driver\Inc;F:\STM32\Cube7\Drivers\BSP\STM32746G-Discovery;F:\STM32\Cube7\Utilities;F:\STM32\Cube7\Utilities\fonts;F:\STM32\Cube7\Middlewares\Third_Party\FatFs\src;F:\STM32\Cube7\Drivers\BSP\Components;F:\STM32\Cube7\Middlewares\Third_Party\FatFs\src\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    F:/STM32/Cube7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_sdram.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_eth.c
    C:/STM32/Cube7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_gpio.c stm32f7xx_ll_usart.c stm32f7xx_ll_rcc.c
  group Application/User
    ../Src/: idrag.c main.c system_misc.c jlcd.c jrtc.c usb_eth_low.c demo.c trans.c stm32746g_discovery_lite.c menu.c adju.c uarts.c s_gpio.c param.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/BSP/STM32746G-DISCOVERY
    F:/STM32/Cube7/Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery_sdram.c stm32746g_discovery_lcd.c stm32746g_discovery_ts.c
    F:/STM32/Cube7/Drivers/BSP/Components/ft5336/: ft5336.c
software components: CMSIS:CORE 4.1.0
